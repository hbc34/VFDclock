# Keil uVision project Project.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: VFDclock +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\DRIVERS\I2C;..\DRIVERS\KEY;..\DRIVERS\SW3518;..\DRIVERS\USART;..\DRIVERS\ADC;..\DRIVERS\VFD;..\DRIVERS\DS3231;..\PAGE;..\sys;..\DRIVERS\FLASH;..\DRIVERS\BMP180;..\DRIVERS\SHT20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h
    ../sys/: HBC_MISC.c sys.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group I2C
    ../DRIVERS/I2C/: I2C.c
  group USART
    ../DRIVERS/USART/: USART.c
  group ADC
    ../DRIVERS/ADC/: ADC.c
  group VFD
    ../DRIVERS/VFD/: VFD.c
  group DS3231
    ../DRIVERS/DS3231/: DS3231.c
  group PAGE
    ../PAGE/: pressure.c screen.c th.c time.c alarm.c
  group KEY
    ../DRIVERS/KEY/: KEY.c
  group FLASH
    ../DRIVERS/FLASH/: FLASH.c
  group BMP180
    ../DRIVERS/BMP180/: BMP180.c
  group SHT20
    ../DRIVERS/SHT20/: SHT20.c
